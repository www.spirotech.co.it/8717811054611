Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_PicoControl Kompact Solo_EPCK-S200-4.0_INT-EN.ifc
Time: 2025-08-05T18:23:02+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_PicoControl Kompact Solo_INT-EN:EPCK-S200-4.0, M_Pressurization_MEPcontent_Spirotech_SpiroExpand_PicoControl Kompact Solo_INT-EN:EPCK-S200-4.0:1850771
In: F00
Type - Material: Color RAL 1003, Color RGB 173-196-207, Color RGB 168-128-048, Color RGB 200-200-200, Color RGB 040-040-040, Color RGB 250-000-000, Color RGB 255-255-255, <Unnamed>, Color RGB 182-182-182, Color RGB 055-055-055
Type - Other - Category: Mechanical Equipment; Angle: 45 deg; Boiler Body Offset: 250 mm; Boiler Height: 1020 mm; Bottom Valve Type: Bottom Connection_Geometry : Bottom Geometry Curved; Depth Body: 160 mm; Diameter: 500 mm; End Valve: 28.3209 mm; Family Name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_PicoControl Kompact Solo_INT-EN; Feet Height: -1087 mm; Front Distance: 200 mm; Height Body: 1070 mm; Leg Radius: 255 mm; Legs Height Body: 1070 mm; Legs Offset: 0 mm; Legs S45: no; Legs S75-500: yes; Nominal Diameter: 19.05 mm; Outer Diameter: 26.9 mm; Pipe Connection Height: 1190 mm; Pipe Depth: 195.24 mm; Pipe Height: 758.567 mm; Pipe Width: 224.13 mm; Radius: 250 mm; Revolve Radius: 250 mm; S125-200: yes; S300: no; S45-75: no; S500: no; Single Leg Height: 1250 mm; Support Distance: 250.17 mm; Support Height: 1087 mm; Support Legs Length: 10 mm; Support Radius: 263 mm; Support S125: yes; Support S200: yes; Support S45: no; Support S75: no; Support Top: yes; Top Geometry S125: no; Top Geometry S200: no; Top Geometry S45: no; Top Geometry S500: no; Top Geometry S75: yes; Total Height: 1515 mm; Valve Radius: 237.867 mm; Vessel Radius S45: 200 mm; Width Body: 400 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 19.05 mm; Depth: 715 mm; Drain Diameter: 15 mm; Height: 1515 mm; Use Nominal Diameter: yes; Width: 505 mm
Type - Electrical Engineering - Voltage: 230 V
Type - Electrical - Loads - Power: 220 W
Type - Identity Data - Article Description: PicoControl Kompact Solo - 200 ltr - 4.0 bar; Article Type: EPCK-S200-4.0; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: PicoControl Kompact Solo - 200 ltr - 4.0 bar; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 12.24; GLN: 8717811000007; GTIN: 8717811054611; Manufacturer: Spirotech; Manufacturer Art. No.: EPCK-S200-4.0; Manufacturer URL: https://www.spirotech.com/8717811054611; MEPcontent Class: VACUUM_DEGASSER; Model: EPCK-S200-4.0; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: EPCK-S200-4.0; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 000-100-200; Bottom Geometry Color: Color RAL 1003; Dark Grey: Color RGB 182-182-182; Grey: Color RGB 200-200-200; Light Black: Color RGB 055-055-055; Light Blue: Color RGB 173-196-207; Top Geometry Color: Color RAL 1003; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Mechanical - Maximum Installation Volume: 0.2 m3; Maximum Water / Glycol (%): 35; Temperature Range (°C): 0-70; Weight: 89 kg
Type - Mechanical - Loads - Workload: 4 Pa
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EPCK-S200-4.0; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EPCK-S200-4.0
Other - Back Clearance Safe: 0 mm; Family: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_PicoControl Kompact Solo_INT-EN; Family and Type: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_PicoControl Kompact Solo_INT-EN: EPCK-S200-4.0; Front Clearance Safe: 500 mm; Left Clearance Safe: 500 mm; Right Clearance Safe: 500 mm; Top Clearance Safe: 500 mm; Type: EPCK-S200-4.0; Type Id: 1850749
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 11.6133 m2; Volume: 0.262883 m3
Identity Data - Mark: 4
Mechanical - Drain Fixture Units: 0; System Classification: Power,Sanitary,Undefined
Mechanical - Flow - Flow In: 0 m3/s; Flow Out: 0 m3/s; Refil Flow: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Back Clearance: 0 mm; Front Clearance: 500 mm; Left Clearance: 500 mm; Right Clearance: 500 mm; Show Service Area: no; Top Clearance: 500 mm

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection | PredefinedType
Port_1850771_1 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
OutPort_1850771_6 | SOURCE | PIPE | SystemType: SEWAGE
InPort_1850771_8 | SINK | PIPE
OutPort_1850771_9 | SOURCE | PIPE
InPort_1850771_10 | SINK | PIPE
